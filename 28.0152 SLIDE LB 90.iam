# Autodesk Inventor assembly: 28.0152 SLIDE LB 90
## iProperties
Created: 2007-06
Part Number: 28.0152 SLIDE LB 90
Document SubType Name: Assembly
Designer: Andy Moles
Author: Andy Moles
